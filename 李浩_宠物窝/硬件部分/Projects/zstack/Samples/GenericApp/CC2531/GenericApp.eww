<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\GenericApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>GenericApp</project>
        <configuration>CoordinatorUSB</configuration>
      </member>
      <member>
        <project>GenericApp</project>
        <configuration>RouterUSB</configuration>
      </member>
      <member>
        <project>GenericApp</project>
        <configuration>EndDeviceUSB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


