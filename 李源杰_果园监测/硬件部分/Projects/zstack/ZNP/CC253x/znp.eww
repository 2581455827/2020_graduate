<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CC2530.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CC2531.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CC2530</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>CC2530</project>
        <configuration>TestHex</configuration>
      </member>
      <member>
        <project>CC2530</project>
        <configuration>ProdSBL</configuration>
      </member>
      <member>
        <project>CC2530</project>
        <configuration>ProdHex</configuration>
      </member>
      <member>
        <project>CC2531</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>CC2531</project>
        <configuration>TestHex</configuration>
      </member>
      <member>
        <project>CC2531</project>
        <configuration>ProdSBL</configuration>
      </member>
      <member>
        <project>CC2531</project>
        <configuration>ProdHex</configuration>
      </member>
      <member>
        <project>CC2530</project>
        <configuration>TVSA_Hex</configuration>
      </member>
      <member>
        <project>CC2530</project>
        <configuration>TVSA_ZC_Hex</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


